<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\libboard_sam3s-ek\build\ewarm_550\libboard_sam3s-ek.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\libchip_sam3s\build\ewarm_550\libchip_sam3s1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\libchip_sam3s\build\ewarm_550\libchip_sam3s2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\libchip_sam3s\build\ewarm_550\libchip_sam3s4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\rtos\CoOS\build\ewarm_550\libCoOS.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\rtos\FreeRTOS\build\ewarm_550\libfreertos.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\libjpeg\build\ewarm_550\libjpeg.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\memories\build\ewarm_550\libmemories_sam3s.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\sam-gui\build\ewarm_550\libsam_gui.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\usb\build\ewarm_550\libusb_sam3s.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>libboard_sam3s-ek</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sam3s-ek</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam3s1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam3s1</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam3s2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam3s2</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam3s4</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam3s4</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libCoOS</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libCoOS</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libfreertos</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libfreertos</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libjpeg</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libjpeg</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libmemories_sam3s</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libmemories_sam3s</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libsam_gui</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libsam_gui</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libusb_sam3s</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libusb_sam3s</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


