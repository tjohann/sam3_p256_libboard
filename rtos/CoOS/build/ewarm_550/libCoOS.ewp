# IAR project libCoOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: ../../; ../../kernel; ../../portable
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: libCoOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: libcoos.h
  group kernel
    ../../kernel/: coocox.h CoOS.h core.c event.c flag.c hook.c kernelHeap.c mbox.c mm.c mutex.c OsConfig.h OsCore.h OsError.h OsEvent.h OsFlag.h OsKernelHeap.h OsMM.h OsMutex.h OsQueue.h OsServiceReq.h OsTask.h OsTime.h OsTimer.h queue.c sem.c serviceReq.c task.c time.c timer.c utility.c utility.h
  group portable
    ../../portable/: arch.c OsArch.h
    ../../portable/IAR/: portForM3.asm
