<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\libusb_sam3s.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>build_all</name>
      <member>
        <project>libusb_sam3s</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libusb_sam3s</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


