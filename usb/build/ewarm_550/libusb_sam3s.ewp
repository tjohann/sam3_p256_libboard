# IAR project libusb_sam3s.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  ICCARM.CCDefines: TRACE_LEVEL=5
  ICCARM.CCIncludePath2: ../../../libboard_sam3s-ek; ../../../libchip_sam3s; ../../../memories; ../../../usb/include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: libusb_sam3s.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  ICCARM.CCDefines: NDEBUG; TRACE_LEVEL=2
  ICCARM.CCOptLevel: 3
  group include
    ../../include/: AUDDescriptors.h AUDDFunction.h AUDDSpeakerDriver.h AUDDSpeakerPhone.h AUDDSpeakerPhoneDriver.h AUDDStream.h AUDRequests.h CDCAUDDDriver.h CDCDescriptors.h CDCDSerial.h CDCDSerialDriver.h CDCDSerialPort.h CDCHIDDDriver.h CDCMSDDriver.h CDCNotifications.h CDCRequests.h DUALCDCDDriver.h HIDAUDDDriver.h HIDDescriptors.h HIDDFunction.h HIDDKeyboard.h HIDDKeyboardDriver.h HIDDMouseDriver.h HIDDTransferDriver.h HIDMSDDriver.h HIDReports.h HIDRequests.h HIDUsages.h MSD.h MSDDriver.h MSDDStateMachine.h MSDescriptors.h MSDFunction.h MSDIOFifo.h MSDLun.h SBC.h SBCMethods.h USBD.h USBD_HAL.h USBDDriver.h USBDescriptors.h USBLib_Trace.h USBLib_Types.h USBRequests.h
  group source/common
    ../../common/audio/: AUDFeatureUnitRequest.c AUDGenericRequest.c
    ../../common/cdc/: CDCLineCoding.c CDCSetControlLineStateRequest.c
    ../../common/hid/: HIDIdleRequest.c HIDKeypad.c HIDReportRequest.c
    ../../common/core/: USBDescriptors.c USBRequests.c
  group source/device
    ../../device/composite/: AUDDFunction.c CDCAUDDDriver.c CDCHIDDDriver.c CDCMSDDriver.c DUALCDCDDriver.c HIDAUDDDriver.c HIDMSDDriver.c
    ../../device/audio-speaker/: AUDDSpeakerDriver.c AUDDSpeakerDriver_Callbacks.c
    ../../device/audio-speakerphone/: AUDDSpeakerPhoneDriver.c AUDDSpeakerPhoneDriver_Callbacks.c AUDDStream.c
    ../../device/cdc-serial/: CDCDSerial.c CDCDSerialDriver.c CDCDSerialDriver_Callbacks.c CDCDSerialPort.c
    ../../device/hid-transfer/: HIDDFunction.c HIDDTransferDriver.c
    ../../device/hid-keyboard/: HIDDKeyboard.c HIDDKeyboardCallbacks_LedsChanged.c HIDDKeyboardDriver.c HIDDKeyboardInputReport.c HIDDKeyboardOutputReport.c
    ../../device/hid-mouse/: HIDDMouseDriver.c
    ../../device/massstorage/: MSDDriver.c MSDDStateMachine.c MSDFunction.c MSDIOFifo.c MSDLun.c SBCMethods.c
    ../../device/core/: USBD.c USBDCallbacks.c USBDDriver.c USBDDriverCallbacks.c
