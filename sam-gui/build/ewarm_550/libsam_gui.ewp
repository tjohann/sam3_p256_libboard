# IAR project libsam_gui.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  ICCARM.CCDefines: sam3s4; SAM_PORTING=1
  ICCARM.CCIncludePath2: ../../; ../../../libchip_sam3s; ../../../libboard_sam3s-ek; ../../../fat; ../../../; ../../../rtos/FreeRTOS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: sam_gui.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG; sam3s4; SAM_PORTING=1
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libsam_gui.out
  group (top)
    ../../: libsam_gui.h
  group common
    ../../source/common/: sam_gui_bitmap_raw.c sam_gui_bitmap_raw.h sam_gui_color.c sam_gui_color.h sam_gui_colors.c sam_gui_colors.h sam_gui_errors.h sam_gui_font.c sam_gui_font.h sam_gui_font10x14.c sam_gui_font10x14.h sam_gui_point.c sam_gui_point.h sam_gui_size.c sam_gui_size.h
  group disp
    ../../source/disp/: disp_backend.c disp_backend.h disp_core.c disp_core.h
  group file
    ../../source/file/: fatfs_config.h file_fs.h
  group porting
    ../../source/porting/: sam_gui_freertos.c sam_gui_porting.h
  group wgt/core
    ../../source/wgt/core/: wgt_core.c wgt_core.h wgt_core_behaviour.c wgt_core_behaviour.h wgt_core_behaviour_default.c wgt_core_frontend.c wgt_core_frontend.h wgt_core_message.c wgt_core_message.h wgt_core_pointer.c wgt_core_pointer.h wgt_core_screen.c wgt_core_screen.h wgt_core_timer.c wgt_core_timer.h wgt_core_widget.c wgt_core_widget.h
  group wgt/widgets
    ../../source/wgt/widgets/: wgt_widget_button.c wgt_widget_button.h wgt_widget_page.c wgt_widget_page.h wgt_widget_static.c wgt_widget_static.h
