# IAR project libboard_sam3s-ek.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  ICCARM.CCDefines: sam3s4; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ../../; ../../../libchip_sam3s/
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: sam3s4
  ILINK.IlinkOutputFile: libsam3s.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  ICCARM.CCDefines: NDEBUG; sam3s4
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libboard_sam3s-ek.out
  group (top)
    ../../: board.h
  group include
    ../../include/: ads7843.h at45_spi.h at45d.h bitbanding.h bmp.h board_lowlevel.h board_memories.h clock.h frame_buffer.h hamming.h ili9325.h iso7816_4.h lcd_color.h lcd_draw.h lcd_font.h lcd_font10x14.h lcd_gimp_image.h lcdd.h led.h math.h rand.h timetick.h tsd.h tsd_ads7843.h tsd_com.h uart_console.h wav.h wm8731.h
  group source
    ../../source/: ads7843.c at45_spi.c at45d.c bmp.c board_cstartup_iar.c board_lowlevel.c board_memories.c clock.c frame_buffer.c hamming.c ili9325.c iso7816_4.c lcd_draw.c lcd_font.c lcd_font10x14.c lcdd.c led.c math.c rand.c timetick.c trace.c tsd_ads7843.c tsd_com.c uart_console.c wav.c wm8731.c
