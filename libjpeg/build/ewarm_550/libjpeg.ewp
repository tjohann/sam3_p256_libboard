# IAR project libjpeg.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: ../..; ../../include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: libjpeg.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: libjpeg.c libjpeg.h
  group headers
    ../../include/: cdjpeg.h jinclude.h jmorecfg.h jpeglib.h
  group headers for sam
    ../../include/: jconfig.h
    ../../: jconfig_gcc.h jconfig_iar.h jconfig_mdk.h
  group source
    ../../source/: jcapimin.c jcapistd.c jcomapi.c jcparam.c jctrans.c jdapimin.c jdapistd.c jdtrans.c
  group source/common
    ../../source/: jaricom.c jerror.c jmemmgr.c jmemnobs.c jutils.c
  group source/compression
    ../../source/: jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcprepct.c jcsample.c jdatadst_mem.c jdatadst_stdio.c jfdctflt.c jfdctfst.c jfdctint.c
  group source/decompression
    ../../source/: jdarith.c jdatasrc_mem.c jdatasrc_stdio.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jidctflt.c jidctfst.c jidctint.c jquant1.c jquant2.c
  group source/excluded
    ../../source/: ansi2knr.c cdjpeg.c cjpeg.c ckconfig.c djpeg.c example.c jdatadst.c jdatasrc.c jmemansi.c jmemdos.c jmemmac.c jmemname.c jpegtran.c memsrc.c rdbmp.c rdcolmap.c rdgif.c rdjpgcom.c rdppm.c rdrle.c rdswitch.c rdtarga.c transupp.c wrbmp.c wrgif.c wrjpgcom.c wrppm.c wrrle.c wrtarga.c
