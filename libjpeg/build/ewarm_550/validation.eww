<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\libjpeg.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>build_all</name>
      <member>
        <project>libjpeg</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libjpeg</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


