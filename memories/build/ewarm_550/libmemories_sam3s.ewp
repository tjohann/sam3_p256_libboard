# IAR project libmemories_sam3s.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  ICCARM.CCDefines: sam3s4; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ../../../libboard_sam3s-ek; ../../../libchip_sam3s; ../../; ../../include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: libsam3s.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG; sam3s4; TRACE_LEVEL=2
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libmemories_sam3s.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: MEDDdram.c MEDFlash.c Media.c MEDNandFlash.c MEDRamDisk.c MEDSdcard.c MEDSdmmc.c MEDSdram.c memories.h
  group nandflash
    ../../nandflash/: EccNandFlash.c ManagedNandFlash.c MappedNandFlash.c NandFlashModel.c NandFlashModelList.c NandSpareScheme.c NfcRawNandFlash.c RawNandFlash.c SkipBlockNandFlash.c TranslatedNandFlash.c
  group norflash
    ../../norflash/: NorFlashAmd.c NorFlashApi.c NorFlashCFI.c NorFlashCommon.c NorFlashIntel.c
  group sdmmc
    ../../sdmmc/: mci_cmd.c mci_cmd_pdc.c sdmmc.c
