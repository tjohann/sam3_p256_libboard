# IAR project libchip_sam3s4.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  ICCARM.CCDefines: sam3s4; TRACE_LEVEL=3
  ICCARM.CCIncludePath2: ../../; ../../cmsis; ../../../usb/include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: libsam3s.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  ICCARM.CCDefines: NDEBUG; sam3s4; TRACE_LEVEL=2
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libchip_sam3s.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: chip.h
  group cmsis
    ../../cmsis/: core_cm3.c core_cm3.h
  group include
    ../../include/: acc.h adc.h async.h crccu.h dacc.h efc.h exceptions.h flashd.h hsmci.h pio.h pio_capture.h pio_it.h pmc.h pwmc.h rtc.h rtt.h SAM3S.h spi.h spi_pdc.h ssc.h tc.h trace.h twi.h twid.h usart.h USBD_Config.h USBD_LEDs.h wdt.h
  group source
    ../../source/: acc.c adc.c async.c crccu.c dacc.c efc.c exceptions.c flashd.c hsmci.c hsmci_pdc.c pio.c pio_capture.c pio_it.c pmc.c pwmc.c rtc.c rtt.c spi.c spi_pdc.c ssc.c tc.c twi.c twid.c usart.c USBD_HAL.c wdt.c
